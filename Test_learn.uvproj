# Keil uVision project Test_learn.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E54B Winbond
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: Test_learn +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c View.c IIC.c func_ir.c constant.c EEPROM.c TUNER.C
